# Keil uVision project epm2.uvproj, settings and files
target epmtest (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: epmtest +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1
  c define: EPM_PROJECT, CONFIG_YAFFS_DIRECT, CONFIG_YAFFS_SHORT_NAMES_IN_RAM, CONFIG_YAFFS_YAFFS2, NO_Y_INLINE, CONFIG_YAFFS_PROVIDE_DEFS, CONFIG_YAFFSFS_PROVIDE_VALUES
  c misc: --c99
  c include: .\src;..\..\common\src\BSP\Driver\Include;..\..\common\src\FreeRTOS;..\..\common\src\FreeRTOS\Source\include;..\..\common\src\FreeRTOS\Source\portable\RVDS\ARM926EJ-S;..\..\common\src\BSP\ThirdParty\FATFS\src;.\src\userdrv;.\src\syshal;.\src\user;.\src\userdrv\vl53l0x\core\inc;.\src\userdrv\vl53l0x\platform\inc;.\src\syshal\json;.\src\syshal\modemlib;..\..\common\src\BSP\ThirdParty\yaffs2;..\..\common\src\BSP\ThirdParty\yaffs2\include;..\..\common\src\BSP\ThirdParty\yaffs2\include\asm;..\..\common\src\BSP\ThirdParty\yaffs2\include\linux;.\src\syshal\yaffs2;..\..\common\src\BSP\Library\SmartcardLib\Include;.\src\syshal\cardlib;.\src\syshal\cardlog;.\src\syshal\blk;..\..\common\src\BSP\Library\USB_HOST\Inc;..\..\common\src\BSP\Library\USB_HOST\Inc\usb_uvc
  memory RVCT1: ROM 0x0 size 0x4000000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\common\src\BSP\Script\nuc970.sct
  link misc: --entry 0
  group src
    ./src/: main.c
  group library
    ../../common/lib/: freertos.lib
  group nuc970 driver
    ../../common/src/BSP/Driver/Source/: sys.c sys_timer.c sys_uart.c system_nuc970.c startup_NUC970.s sys_nuc970.s uart.c standalone.c gpio.c rtc.c spi.c i2c.c sdh.c pwm.c adc.c etimer.c sc.c mtp.c crypto.c
    ../../common/src/BSP/Library/SmartcardLib/: SmartCardLib_Keil.lib
  group user
    ./src/User/: user.c guistandby.c guimanager.c meterdata.c guiselspace.c guiseltime.c guireaderinit.c guideposit.c guidepositfail.c guidepositok.c guireplacebp.c guitester.c guitesterkeypad.c
    ./src/user/: paralib.c guifiledownload.c guifree.c hwtester.c guihardwaretest.c guisingletest.c guitool.c guifactory.c guisettingid.c guishowcardid.c guiradar.c guiusbcam.c guilidar.c guinull.c guicalibration.c guiversion.c guiblank.c guiepdflashtool.c guiradarotatool.c guiburnintester.c guirtctool.c guiradartool.c
  group syshal
    ./src/user/: guioff.c
    ./src/SysHal/: halinterface.c guidrv.c keydrv.c powerdrv.c timerdrv.c cardreader.c epddrv.c spacedrv.c timelib.c ts2000drv.c pct08cmdlib.c pct08drv.c fatfslib.c photoagent.c jsoncmdlib.c dataagent.c cmdlib.c ts1000drv.c
    ./src/syshal/: modemagent.c tarifflib.c yaffs2drv.c dataprocesslib.c loglib.c ledcmdlib.c leddrv.c fileagent.c sflashrecord.c spaceexdrv.c uvcdrv.c creditReaderDrv.c MtpProcedure.c
  group userdrv
    ./src/UserDrv/: userdrv.c uart2drv.c uart8drv.c uart10drv.c spi0drv.c spi1drv.c i2c1drv.c buzzerdrv.c batterydrv.c dipdrv.c rs232CommDrv.c flashdrvex.c sddrv.c sr04tdrv.c
    ./src/userdrv/: uart0drv.c uart1drv.c uart3drv.c uart4drv.c uart7drv.c mtp232CommDrv.c nt066edrv.c smartcarddrv.c interface.c radardrv.c lidardrv.c burnintester.c fwremoteota.c rb60pOTA.c
  group fatfs
    ./src/SysHal/fatfs/: ccsbcs.c diskio.c
    ../../common/src/BSP/ThirdParty/FATFS/src/: ff.c
  group json
    ./src/SysHal/json/: cJSON.c cJSON_Utils.c
  group modemlib
    ./src/syshal/modemlib/: atcmdparser.c quentelmodemlib.c
  group yaffs2
    ../../common/src/BSP/ThirdParty/yaffs2/: mtdcore.c mtdpart.c nand.c nand_base.c nand_bbt.c nand_ids.c nand_util.c yaffs_allocator.c yaffs_attribs.c yaffs_bitmap.c yaffs_checkptrw.c yaffs_ecc.c yaffs_error.c yaffs_guts.c yaffs_malloc.c yaffs_mtdif.c yaffs_mtdif2.c yaffs_nameval.c yaffs_nand.c yaffs_packedtags1.c yaffs_packedtags2.c yaffs_qsort.c yaffs_summary.c yaffs_tagscompat.c yaffs_verify.c yaffs_yaffs1.c yaffs_yaffs2.c yaffsfs.c
    ../../common/src/BSP/ThirdParty/yaffs2/platform/: fmi_nand.c
  group cardlib
    ./src/syshal/cardlib/: ecclib.c epmreader.c ipasslib.c
  group cardlog
    ./src/syshal/cardlog/: cardlogcommon.c ecclog.c ipassdpti.c
  group blk
    ./src/syshal/blk/: blkcommon.c eccblk.c ipassblk.c
  group src_usb_core
    ../../common/src/BSP/Library/USB_HOST/src_core/: ehci.c ehci_iso.c hub.c mem_alloc.c ohci.c support.c usb_core.c
  group uvc
    ../../common/src/BSP/Library/USB_HOST/src_uvc/: uvc_core.c uvc_driver.c uvc_parser.c
  group octopus
    ./src/syshal/octopus/: csdes.c csrw.c octopusreader.c rwl.c rwlfunc.c
